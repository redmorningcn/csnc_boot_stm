<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\boot_stm32f10x.ewp</path>
  </project>
  <batchBuild/>
</workspace>


